# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS_Demo (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  AfterMake: fromelf --bin --output .\rvmdk\RTOSDemo.bin .\rvmdk\RTOSDemo.axf
  c flags: Optim=1 OneElfS=1
  c define: RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END="
  c misc: --diag_suppress 191,550,513,167,177,144
  c include: .;.\..\Common\drivers\LuminaryMicro;..\..\Source\portable\RVDS\ARM_CM3;..\..\Source\include;..\Common\include;..\Common\ethernet\uIP\uip-1.0\uip;.\webserver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Demo_Source
    ../Common/Minimal/: integer.c Logging.c LogQueue.c
    ./: main.c startup_rvmdk.S FreeRTOSConfig.h
  group Libraries
    ../Common/drivers/LuminaryMicro/Keil/: driverlib.lib grlib.lib
    ./: osram128x64x4.c rit128x96x4.c formike128x128x16.c
  group RTOS_Source
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
